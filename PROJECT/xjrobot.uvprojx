# Keil uVision project xjrobot.uvprojx, settings and files
target xjrobot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: xjrobot +hex
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\HARDWARE;..\STM32_LIB\inc;..\STM32_LIB\src;..\SYSTEM;..\USER\CONFIG;..\USER\TASK_APP;..\USER\uC-CPU;..\USER\UCOSII\CORE;..\USER\UCOSII\PORT;..\USER;..\USER\uCOS-VIEW\Source;..\USER\uCOS-VIEW\Ports\ARM-Cortex-M3\Realview;..\USER\uC-LIB\Ports\RealView;..\USER\uC-LIB;..\USER\HARDWARE;..\USER\TASK_APP;..\USER\CONFIG
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group TASK_APP
    ../USER/: main.c
    ../USER/TASK_APP/: Task_Weather.c Task_Remote_Rec.c Task_Local.c Task_Timer.c Task_Sensor_Data_Collect.c
  group USER
    ../USER/: stm32f4xx_it.c stm32f4xx_conf.h
    ../USER/CONFIG/: app_cfg.h includes.h
  group DRIVERS
    ../USER/TASK_APP/: cmd_para.c str.c zt_motor_master_driver.c zt_motor_slave_driver.c AM2320_By_IIC.c uart_api.c
  group HARDWARE
    ../USER/HARDWARE/: delay.c BSP_led.c board.c BSP_Limit_SW.c BSP_pressure_sensor.c BSP_ADC_Init.c BSP_enccoder.c BSP_motor_cal_speed.c BSP_GPS.c NVIC_IRQ.c BSP_Video_TRANS.c BSP_HI3521.c BSP_Debug.c
  group STM32_LIB
    ../STM32_LIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group STARTUP_CORE
    ../CORE/: startup_stm32f40_41xxx.s
    ../USER/: system_stm32f4xx.c
  group UCOSII_CONFIG
    ../USER/CONFIG/: os_cfg.h
  group UCOSII_CORE
    ../USER/UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII_PORT
    ../USER/UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group UCOSII_CPU
    ../USER/uC-CPU/: cpu.h cpu_a.asm cpu_def.h cpu_c.c
  group UCOSII/LIB/SOURCE
    ../USER/uC-LIB/: lib_mem.c lib_str.c lib_def.h lib_mem.h lib_str.h
  group UCOSII/LIB/PORT
    ../USER/uC-LIB/Ports/RealView/: lib_mem_a.asm
  group UCOSII/VIEW/PORT
    ../USER/uCOS-VIEW/Ports/ARM-Cortex-M3/Realview/: os_viewc.c os_viewc.h
  group UCOSII/VIEW/SOURCE
    ../USER/uCOS-VIEW/Source/: os_view.c os_view.h
  group README
    ../: readme.txt
